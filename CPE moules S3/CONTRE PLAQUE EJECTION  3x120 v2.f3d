CONTRE PLAQUE EJECTION  3x120 v2 (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Fonction de base"
thread "Filetage"