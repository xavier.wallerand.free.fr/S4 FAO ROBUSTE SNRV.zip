CONTRE PLAQUE EJECTION 1X120 v2 (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Fonction de base"
thread "Filetage"